# Keil uVision project ORI.uvprojx, settings and files
target GPS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Bsp;..\..\User\nmea_decode\include;..\..\User\dam;..\..\User\dht11;..\..\User\dwt_delay;..\..\User\ec20;..\..\User\led;..\..\User\systick;..\..\User\tim;..\..\User\usart1;..\..\User\usart2;..\..\User\Infrared_beam;..\..\User\mlx90614;..\..\User\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_it.c nema_decode_test.c
    ../../User/systick/: bsp_systick.c
    ../../User/dwt_delay/: core_delay.c
    ../../User/dam/: bsp_dma.c
    ../../User/Bsp/gps/: gps_config.c
    ../../User/ec20/: bsp_ec20.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/led/: bsp_led.c
    ../../User/tim/: bsp_tim.c
    ../../User/usart1/: bsp_usart1.c
    ../../User/usart2/: bsp_usart2.c
    ../../User/Infrared_beam/: bsp_exti.c
    ../../User/mlx90614/: mlx90614.c
    ../../User/oled/: OLED_I2C.c
  group nmealib
    ../../User/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
